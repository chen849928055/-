# Keil uVision project HC89F30x_Touch_Library_Code.uvproj, settings and files
target HC89F30x_Touch_Library_Code (MCS-51)
  device: HC89F301 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(32000000)
  output: HC89F30x_Touch_Library_Code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Application;..\..\User\INC;..\..\Libraries;..\..\Utilities
  group HC51_STARTUP
    ../../User/: STARTUP.A51
  group USER
    ../../User/: Main.c
  group Utilities
    ../../Utilities/: key.c eeprom.c timer.c buzzer.c
  group Touch_Lib
    ../../Libraries/HC89F30x_GeneralKey_Touch_Lib_V1.04/: HC89F30x_GeneralKey_Touch_Lib_CFG.c HC89F30x_GeneralKey_Touch_Filter.c HC89F30x_GeneralKey_Touch_Multibutton.c HC89F30x_GeneralKey_Touch_Lib_V1.04.LIB
  group TouchUartDebug_Lib
    ../../Libraries/HC89F30x_TouchUartDebug_Lib_V1.00/: HC89F30x_TouchUartDebug_Lib_CFG.c HC89F30x_TouchUartDebug_Lib_V1.00.LIB
  group Included HC Driver
    ../../User/C/: HC89F30x_IO_INIT.c HC89F30x_ISR.c HC89F30x_PORT_MAP.c HC89F30x_SYS.c
  group ReadMe
    ../../: ReadMe.txt
